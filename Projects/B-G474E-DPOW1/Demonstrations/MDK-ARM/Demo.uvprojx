# Keil uVision project Demo.uvprojx, settings and files
target B-G474E-DPOW1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G474xx,USE_HAL_DRIVER,USE_B_G474E_DPOW1
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../Drivers/BSP/Components/Common;../../../../Drivers/BSP/B-G474E-DPOW1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers/BSP
    ../../../../Drivers/BSP/B-G474E-DPOW1/: b_g474e_dpow1.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_exti.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_opamp.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_rtc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32g474xx.s
  group Example/User
    ../Src/: HW_3p3z_controller.c BuckBoost.c ledRGB.c main.c stm32g4xx_it.c
software components: CMSIS:CORE 4.3.0
