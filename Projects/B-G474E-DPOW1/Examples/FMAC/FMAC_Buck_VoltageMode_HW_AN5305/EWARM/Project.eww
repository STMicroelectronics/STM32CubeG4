<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FMAC_Buck_VoltageMode_HW_AN5305.ewp</path>
  </project>
  <batchBuild />
</workspace>
