<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LPTIM_PWMExternalClock.ewp</path>
  </project>
  <batchBuild />
</workspace>
