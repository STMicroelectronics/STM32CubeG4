# IAR project Project.ewp, settings and files
configuration STM32G474E_EVAL1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx; USE_STM32G474E_EVAL1; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\..\..\Drivers\STM32G4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32G474E-EVAL; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Utilities; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F769I_EVAL1.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/hx8347d
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c hx8347d_reg.c
  group Drivers/BSP/Components/MFXSTM32L152
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/Components/MT25ql512abb
    ../../../../../Drivers/BSP/Components/mt25ql512abb/: mt25ql512abb.c
  group Drivers/BSP/Components/STTS751
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/Components/WM8994
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32G474E_EVAL1
    ../../../../../Drivers/BSP/STM32G474E-EVAL/: stm32g474e_eval.c stm32g474e_eval_audio.c stm32g474e_eval_bus.c stm32g474e_eval_env_sensor.c stm32g474e_eval_idd.c stm32g474e_eval_io.c stm32g474e_eval_lcd.c stm32g474e_eval_qspi.c stm32g474e_eval_sd.c stm32g474e_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smbus.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_fmc.c
  group Drivers/Utilities
    ../../../../../Utilities/LCD/: stm32_lcd.c
  group Example/EWARM
    ./: startup_stm32g474xx.s
  group Example/User
    ../Src/: audio_play.c audio_rec.c bus.c button.c com.c idd.c io.c joystick.c lcd.c led.c main.c potentiometer.c qspi.c sd.c sram.c stm32g4xx_it.c
