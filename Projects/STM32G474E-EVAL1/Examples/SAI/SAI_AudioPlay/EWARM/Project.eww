<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SAI_AudioPlay.ewp</path>
  </project>
  <batchBuild />
</workspace>
