# IAR project CORDIC_SinCos_DMA_Perf.ewp, settings and files
configuration CORDIC_SinCos_DMA_Perf (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474QE ST STM32G474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/DSP/Include; ../../../../../../Drivers/BSP/STM32G474E-EVAL; ../../../../../../Drivers/BSP/Components/mfxstm32l152
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CORDIC_SinCos_DMA_Perf.hex
  ILINK.IlinkOutputFile: CORDIC_SinCos_DMA_Perf.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../Drivers/CMSIS/DSP/Lib/IAR/iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152_reg.c mfxstm32l152.c
  group Drivers/BSP/STM32G474E-EVAL1
    ../../../../../../Drivers/BSP/STM32G474E-EVAL/: stm32g474e_eval_bus.c stm32g474e_eval_io.c stm32g474e_eval.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_gpio.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
