<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FreeRTOS_Signal.ewp</path>
  </project>
  <batchBuild />
</workspace>
