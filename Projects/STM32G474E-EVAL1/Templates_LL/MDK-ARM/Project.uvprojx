# Keil uVision project Project.uvprojx, settings and files
target STM32G474E-EVAL1 (6070000::V6.7::.\ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G474xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../Drivers/STM32G4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_LL_Driver
    ../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32g474xx.s
  group Example/User
    ../Src/: main.c stm32g4xx_it.c
software components: CMSIS:CORE 5.3.0
