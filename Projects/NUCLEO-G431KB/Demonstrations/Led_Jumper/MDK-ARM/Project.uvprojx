# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G431KB (ARM-ADS)
  device: STM32G431KBTx STMicroelectronics
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20007FFF) IRAM(0x10000000-0x100027FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G431xx,USE_HAL_DRIVER,USE_STM32G4XX_NUCLEO_32
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G4xx_Nucleo
  library: MicroLIB
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32g431xx.s
  group Example/User
    ../Src/: main.c stm32g4xx_it.c
software components: CMSIS:CORE 4.3.0
