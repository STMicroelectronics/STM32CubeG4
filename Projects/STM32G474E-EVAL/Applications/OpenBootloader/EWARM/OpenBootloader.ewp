# IAR project OpenBootloader.ewp, settings and files
configuration STM32G474E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474QE ST STM32G474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\OpenBootloader\App; ..\OpenBootloader\Target; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\USART; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\FDCAN; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\Mem; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Core; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\..\..\Drivers\STM32G4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OpenBootloader.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../Core/Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c fdcan_interface.c flash_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c systemmemory_interface.c usart_interface.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_usart_ex.c stm32g4xx_ll_gpio.c stm32g4xx_ll_rcc.c stm32g4xx_ll_usart.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/FDCAN
    ../../../../../Middlewares/ST/OpenBootloader/Modules/FDCAN/: openbl_fdcan_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
