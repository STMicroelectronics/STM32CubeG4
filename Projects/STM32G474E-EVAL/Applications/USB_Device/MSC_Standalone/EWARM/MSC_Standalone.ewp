# IAR project MSC_Standalone.ewp, settings and files
configuration MSC_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474QE ST STM32G474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ../USB_Device/App; ../USB_Device/Target; ../Core/Inc; ../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32G474E-EVAL; ../../../../../../Drivers/BSP/Components/mfxstm32l152
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MSC_Standalone.hex
  ILINK.IlinkOutputFile: MSC_Standalone.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usbd_desc.c usbd_storage_if.c usb_device.c
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G474E-EVAL
    ../../../../../../Drivers/BSP/STM32G474E-EVAL/: stm32g474e_eval_sd.c stm32g474e_eval_bus.c stm32g474e_eval_io.c stm32g474e_eval.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152_reg.c mfxstm32l152.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
