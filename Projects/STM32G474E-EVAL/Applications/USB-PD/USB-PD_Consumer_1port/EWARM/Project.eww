<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB-PD_Consumer_1port.ewp</path>
  </project>
  <batchBuild />
</workspace>
