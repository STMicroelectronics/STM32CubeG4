<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB-PD_Provider_1port.ewp</path>
  </project>
  <batchBuild />
</workspace>
