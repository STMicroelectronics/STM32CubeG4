<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\OPAMP_PGA_ExternalBias.ewp</path>
  </project>
  <batchBuild />
</workspace>
