<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\OPAMP_InternalFollower.ewp</path>
  </project>
  <batchBuild />
</workspace>
