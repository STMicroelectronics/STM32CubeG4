<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FDCAN_Com_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>
