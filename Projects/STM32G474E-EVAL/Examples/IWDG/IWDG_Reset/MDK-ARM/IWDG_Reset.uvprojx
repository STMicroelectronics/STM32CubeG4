# Keil uVision project IWDG_Reset.uvprojx, settings and files
target IWDG_Reset (ARM-ADS)
  device: STM32G474QETx STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: IWDG_Reset +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,
  c include: ../Inc;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32G474E-EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G474E-EVAL
    ../../../../../../Drivers/BSP/STM32G474E-EVAL/: stm32g474e_eval_bus.c stm32g474e_eval_io.c stm32g474e_eval.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152_reg.c mfxstm32l152.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_comp.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
