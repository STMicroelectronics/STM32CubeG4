<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CRC_Bytes_Stream_7bit_CRC.ewp</path>
  </project>
  <batchBuild />
</workspace>
