# Keil uVision project Project.uvprojx, settings and files
target STM32G474E_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x0-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,USE_STM32G474E_EVAL,USE_IOEXPANDER,__DBG_ITM
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G474E-EVAL;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components;../../../../../Utilities;../../../../../Utilities/Log;../../../../../Utilities/Fonts;../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/hx8347d
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c hx8347d_reg.c
  group Drivers/BSP/Components/MFXSTM32L152
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/Components/MT25ql512abb
    ../../../../../Drivers/BSP/Components/mt25ql512abb/: mt25ql512abb.c
  group Drivers/BSP/Components/STTS751
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/Components/WM8994
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32G474E_EVAL
    ../../../../../Drivers/BSP/STM32G474E-EVAL/: stm32g474e_eval.c stm32g474e_eval_audio.c stm32g474e_eval_bus.c stm32g474e_eval_env_sensor.c stm32g474e_eval_idd.c stm32g474e_eval_io.c stm32g474e_eval_lcd.c stm32g474e_eval_qspi.c stm32g474e_eval_sd.c stm32g474e_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_smbus.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_fmc.c
  group Drivers/Utilities
    ../../../../../Utilities/Basic_GUI/: basic_gui.c
  group Example/MDK-ARM
    ./: startup_stm32g474xx.s
  group Example/User
    ../Src/: audio_play.c audio_rec.c bus.c button.c com.c idd.c io.c joystick.c lcd.c led.c main.c potentiometer.c qspi.c sd.c sram.c stm32g4xx_it.c
    ./: Retarget.c Serial.c
software components: CMSIS:CORE 4.3.0
