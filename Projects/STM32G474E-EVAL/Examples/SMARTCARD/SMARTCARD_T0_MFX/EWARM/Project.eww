<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SMARTCARD_T0_MFX.ewp</path>
  </project>
  <batchBuild />
</workspace>
