# Keil uVision project Demo.uvprojx, settings and files
target STM32G474E-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IROM(0x08000000-0x807F7FF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32G474E-EVAL_DEMO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G474xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,USE_STM32G474E_EVAL,USE_IOEXPANDER,MB1397,_SNK,_DRP,_RTOS,USBPDCORE_LIB_PD3_FULL,USBPD_PORT_COUNT=1,__DEBUG_CAD,_TRACE,_PPS=USBPD_FALSE,_SRC_CAPA_EXT=USBPD_FALSE,_ALERT=USBPD_TRUE,_BATTERY=USBPD_FALSE,_STATUS=USBPD_TRUE,_MANU_INFO=USBPD_TRUE,_VDM,_GUI_INTERFACE,ARM_MATH_CM4
  c include: ../Inc;../../Config;../../Common/Inc;../../Core/Inc;../../Demo/Modules/lowpower;../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/DSP/Include;../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G474E-EVAL;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G4xx/inc;../../Modules/audio;../../Modules/lowpower;../../Modules/filebrowser;../../Modules/calendar;../../Modules/imagebrowser;../../Modules/main_app;../../Modules/thermometer;../../Modules/whiteled;../../Modules/math;../../Modules/ucpd;../../../../../Utilities/LCD;../../../../../Utilities/TRACER_EMB;../../../../../Utilities/GUI_INTERFACE
  asm include: ../Config;../../Modules/ucpd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7f800
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Application/Common
    ../../Common/Src/: sd_diskio.c utils.c
  group Application/Core
    ../../Core/Src/: k_demo.c k_menu.c k_module.c k_storage.c k_tools.c k_widgets.c k_window.c
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/Modules/AppMain
    ../../Modules/main_app/: app_main.c
  group Application/Modules/Audio
    ../../Modules/audio/: app_audio.c wave_player.c wave_recorder.c
  group Application/Modules/Calendar
    ../../Modules/calendar/: app_calendar.c
  group Application/Modules/FilesBrowser
    ../../Modules/filebrowser/: app_filesbrowser.c
  group Application/Modules/ImagesBrowser
    ../../Modules/imagebrowser/: app_imagesbrowser.c
  group Application/Modules/LowPower
    ../../Modules/lowpower/: app_lowpower.c
  group Application/Modules/Math
    ../../Modules/math/: app_math.c
  group Application/Modules/Tsensor
    ../../Modules/thermometer/: app_thermometer.c
  group Application/Modules/Ucpd
    ../../Modules/ucpd/: app_ucpd.c demo_application.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_vdm_user.c
  group Application/Modules/WhiteLed
    ../../Modules/whiteled/: app_whiteled.c
  group Application/User
    ../Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c hx8347d_reg.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32G474E-EVAL
    ../../../../../Drivers/BSP/STM32G474E-EVAL/: stm32g474e_eval.c stm32g474e_eval_audio.c stm32g474e_eval_bus.c stm32g474e_eval_env_sensor.c stm32g474e_eval_io.c stm32g474e_eval_lcd.c stm32g474e_eval_sd.c stm32g474e_eval_usbpd_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Drivers
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_dma.c stm32g4xx_ll_rcc.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_utils.c
  group Drivers/CMSIS/DSP/Lib/IAR
    ../../../../../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4l_math.lib
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c usbpd_trace.c
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM4_Keil.lib
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32G4XX
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G4XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Utilities/LCD
    ../../../../../Utilities/LCD/: stm32_lcd.c
  group Utilities/GUI_INTERFACE
    ../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
  group Utilities/Tracer_Emb
    ../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
software components: CMSIS:CORE 4.3.0
