# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G431RB_COMP_CompareGpioVsVrefInt_IT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.1
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20007FFF) IRAM(0x10000000-0x100027FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G431xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G4xx_LL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32g431xx.s
  group Example/User
    ../Src/: main.c stm32g4xx_it.c
software components: CMSIS:CORE 4.3.0
