<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I2C_OneBoard_Communication_IT_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>
