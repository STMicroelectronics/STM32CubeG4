<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SPI_TwoBoards_FullDuplex_DMA_Master_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>
