# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G431RB_SPI_OneBoard_HalfDuplex_DMA (ARM-ADS)
  device: STM32G431RBTx STMicroelectronics
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20007FFF) IRAM(0x10000000-0x100027FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G431xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc
  library: MicroLIB
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c stm32g4xx_it.c
  group Drivers/STM32G4xx_LL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Example/MDK-ARM
    ./: startup_stm32g431xx.s
software components: CMSIS:CORE 4.3.0
