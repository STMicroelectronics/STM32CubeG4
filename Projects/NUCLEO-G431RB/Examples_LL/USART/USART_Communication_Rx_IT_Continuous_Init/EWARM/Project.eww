<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USART_Communication_Rx_IT_Continuous_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>
