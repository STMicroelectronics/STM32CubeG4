<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTC_LSI.ewp</path>
  </project>
  <batchBuild />
</workspace>
