<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_ComDMA_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>
