<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CORDIC_SinCos_DMA_Perf.ewp</path>
  </project>
  <batchBuild />
</workspace>
