<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RCC_CRS_Synchronization_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>
