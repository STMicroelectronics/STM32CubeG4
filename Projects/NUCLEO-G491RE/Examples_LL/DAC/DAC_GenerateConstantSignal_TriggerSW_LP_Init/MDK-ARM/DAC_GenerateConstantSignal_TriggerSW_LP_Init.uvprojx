# Keil uVision project DAC_GenerateConstantSignal_TriggerSW_LP_Init.uvprojx, settings and files
target DAC_GenerateConstantSignal_TriggerSW_LP_Init (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G491RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.4
  cpu: IRAM(0x20000000-0x2001BFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: DAC_GenerateConstantSignal_TriggerSW_LP_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G491xx
  c misc: --wchar32
  c include: ../Inc;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  group Application/MDK-ARM
    ./: startup_stm32g491xx.s
  group Application/User
    ../Src/: main.c stm32g4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
