# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G491RE_COMP_CompareGpioVsVrefInt_IT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G491RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.4
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x10003FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G491xx,USE_FULL_LL_DRIVER
  c misc: --wchar32
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32g4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32g491xx.s
  group Drivers/STM32G4xx_LL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
