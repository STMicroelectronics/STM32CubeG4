# Keil uVision project OpenBootloader.uvprojx, settings and files
target NUCLEO-G491RE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G491RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.4
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x10003FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G491xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../Core/Inc;../OpenBootloader/App;../OpenBootloader/Target;../../../../../Middlewares/ST/OpenBootloader/Core;../../../../../Middlewares/ST/OpenBootloader/Modules/I2C;../../../../../Middlewares/ST/OpenBootloader/Modules/Mem;../../../../../Middlewares/ST/OpenBootloader/Modules/USART;../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../Core/Src;../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/Core
    ../Core/Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32g491xx.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c flash_interface.c i2c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c systemmemory_interface.c usart_interface.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2s.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_ll_i2c.c stm32g4xx_ll_rcc.c stm32g4xx_ll_spi.c stm32g4xx_ll_usart.c stm32g4xx_ll_usb.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
software components: CMSIS:CORE 4.3.0
