# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G474RE_CORTEX_MPU (ARM-ADS)
  device: STM32G474RETx STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32G474xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc
  library: MicroLIB
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32g4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32g474xx.s
  group Drivers/STM32G4xx_LL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
