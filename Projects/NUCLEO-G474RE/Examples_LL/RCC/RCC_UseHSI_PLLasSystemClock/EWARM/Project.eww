<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RCC_UseHSI_PLLasSystemClock.ewp</path>
  </project>
  <batchBuild />
</workspace>
