<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\WWDG_RefreshUntilUserEvent_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>
