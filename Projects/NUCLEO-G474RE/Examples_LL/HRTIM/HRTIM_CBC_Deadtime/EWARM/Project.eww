<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HRTIM_CBC_Deadtime.ewp</path>
  </project>
  <batchBuild />
</workspace>
