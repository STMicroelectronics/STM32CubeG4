<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HRTIM_Basic_Multiple_PWM.ewp</path>
  </project>
  <batchBuild />
</workspace>
