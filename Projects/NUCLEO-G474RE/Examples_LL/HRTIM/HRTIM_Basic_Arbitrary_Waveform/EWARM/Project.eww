<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HRTIM_Basic_Arbitrary_Waveform.ewp</path>
  </project>
  <batchBuild />
</workspace>
