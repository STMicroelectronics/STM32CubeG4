<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HRTIM_Basic_SinglePWM.ewp</path>
  </project>
  <batchBuild />
</workspace>
