<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_ComIT_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>
