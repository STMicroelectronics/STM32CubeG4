<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I2C_TwoBoards_ComPolling.ewp</path>
  </project>
  <batchBuild />
</workspace>
