# Keil uVision project FatFs_uSD_Standalone.uvprojx, settings and files
target FatFs_uSD_Standalone (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: STMicroelectronics.STM32G4xx_DFP.0.0.4
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: FatFs_uSD_Standalone +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_NUCLEO_64,USE_HAL_DRIVER,STM32G474xx,
  c include: ../FATFS/Target;../FATFS/App;../Core/Inc;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32G4xx_Nucleo;../../../../../../Drivers/BSP/Adafruit_Shield
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: stm32g4xx_nucleo_bus.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/BSP/Adafruit802
    ../../../../../../Drivers/BSP/Adafruit_Shield/: adafruit_802_sd.c adafruit_802.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.3.0
