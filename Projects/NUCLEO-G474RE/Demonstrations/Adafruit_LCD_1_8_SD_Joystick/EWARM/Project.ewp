# IAR project Project.ewp, settings and files
configuration NUCLEO-G474RE (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx; USE_STM32G4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\..\..\Drivers\STM32G4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32G4xx_Nucleo; ..\..\..\..\..\Drivers\BSP\Adafruit_Shield; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Utilities\Basic_gui
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo_NUCLEO-G474RE.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: adafruit_802.c adafruit_802_lcd.c adafruit_802_sd.c
  group Drivers/BSP/Components/ST7735
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c st7735_reg.c
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/Utilities/Basic_GUI
    ../../../../../Utilities/Basic_GUI/: basic_gui.c
  group Example/EWARM
    ./: startup_stm32g474xx.s
  group Example/User
    ../Src/: joystick.c lcd.c main.c sd.c stm32g4xx_it.c stm32g4xx_nucleo_bus.c
